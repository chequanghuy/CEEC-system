# Keil uVision project ceecdoorv2.uvprojx, settings and files
target CEEC_DOOR_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ceecdoorv2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;.\ssd1306
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./src/: startup_stm32f10x_md.s
  group CMSIS
    ./src/: core_cm3.c system_stm32f10x.c
  group StdPeriph
    ./src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c
  group User
    ./src/: main.c delay.c User_TIM.c tm_stm32f10x_mfrc522.c User_FLASH.c User_GPIO.c User_Control.c User_USART2.c stm32f10x_iwdg.c stm32f10x_i2c.c
  group Libraries
    ./ssd1306/: fonts.c ssd1306.c ssd1306_i2c.c display.c
